# IAR project Backup of R_dsp_rl78.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: IAR_TOOL
  ICCRL78.CCIncludePath2: include; lib
  ARL78.AsmIncludePath: ..\include; ..\lib
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f104pj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: include
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkrl78_2.xcl
  group (top)
    lib/: R_dscl_filter_rl78.r87
  group src/sample
    sample/: sample_dscl_fir.c sample_dscl_iirbiquad.c sample_dscl_iirsinglepole.c sample_dscl_main.c
